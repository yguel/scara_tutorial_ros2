Commit message: added tool0 frame

File: scara_description/urdf/scara.urdf (robot description, URDF)
Before this commit: robot scara, 8 links, 7 joints
Links:
- added link tool0
Joints:
- added joint tool02link3: type fixed, parent link3, child tool0, origin xyz=0 0 0 rpy=0 0 0, axis 0 0 0
